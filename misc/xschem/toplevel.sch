** sch_path: misc/xschem/toplevel.sch
**.subckt toplevel Vref VDD GND
*.opin Vref
*.iopin VDD
*.iopin GND
x1 VDD net1 Vref GND sumamp
x2 VDD GND net1 ptat
**.ends
.end
