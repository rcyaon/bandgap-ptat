** sch_path: src/bansen.sch
**.subckt bansen Vref VDD GND
*.opin Vref
*.iopin VDD
*.iopin GND
x1 VDD net1 Vref GND sumamp
x2 VDD net1 GND ptat
**.ends
.end
