** sch_path: src/schematics/toplevel.sch
**.subckt toplevel Vref VDD GND
*.opin Vref
*.iopin VDD
*.iopin GND
x1 VDD net1 Vref net1 sumamp
x2 VDD GND GND ptat
**.ends
.end
